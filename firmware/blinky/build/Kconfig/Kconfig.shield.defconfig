## firmware/blinky/build/blinky/Kconfig/boards/Kconfig
```kconfig
# Load Zephyr board Kconfig descriptions.
osource "/opt/nordic/ncs/v3.1.0/zephyr/boards/nordic/nrf52840dk/Kconfig"
```
